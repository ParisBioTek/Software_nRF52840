## firmware/boards/PBT/NRF52840_CUSTOM/board.yml
```yaml
board:
  name: NRF52840_CUSTOM
  full_name: NRF52840_CUSTOM
  vendor: PBT
  socs:
    - name: nrf52840
```
